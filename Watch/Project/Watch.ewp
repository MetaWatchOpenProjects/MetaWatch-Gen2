# IAR project Watch.ewp, settings and files
configuration Gen2 (MSP430)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xmfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 1
  ICC430.CCDefines: DIGITAL; WATCH; BOOTLOADER; SUPPORT_BLE; INCLUDE_1316_PATCH
  ICC430.CCDiagSuppress: Pa050
  ICC430.PreInclude: ..\Application\PreInclude.h
  ICC430.newCCIncludePaths: ..\..\FreeRTOS\include; ..\..\FreeRTOS\portable\MSP430F5438; ..\..\OSAL; ..\Hardware; ..\Hardware\F5xx_F6xx_Core_Lib\; ..\Application; ..\..\Bootloader; ..\..\Stack\Api
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: LinkerConfigurationBootloader.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -C ..\..\Stack\Api\IAR\wrapper.r43; -C ..\..\Stack\Api\IAR\stack.a; -C ..\..\Stack\Api\IAR\libgat.a; -C ..\..\Stack\Api\IAR\libmap.a; -C ..\..\Bootloader\Api\IAR\Bootloader.r43
configuration Gen1 (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: DIGITAL; WATCH; INCLUDE_1315_PATCH
  ICC430.newCCIncludePaths: ..\..\FreeRTOS\include; ..\..\FreeRTOS\portable\MSP430F5438; ..\..\OSAL; ..\Hardware; ..\Hardware\F5xx_F6xx_Core_Lib\; ..\Application; ..\..\Stack\Api; ..\..\Bootloader
  XLINK.XclFile: LinkerConfiguration.xcl
  XLINK.XExtraOptions: -C ..\..\Stack\Api\IAR\wrapper1.r43; -C ..\..\Stack\Api\IAR\stack.a
configuration Bootloader (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: DIGITAL; WATCH; SUPPORT_BLE; INCLUDE_1316_PATCH; BOOTLOADER
  ICC430.newCCIncludePaths: as above
  XLINK.XExtraOptions: -C ..\..\Stack\Api\IAR\wrapper.r43; -C ..\..\Bootloader\Api\IAR\Bootloader.r43; -C ..\..\Stack\Api\IAR\stack.a; -C ..\..\Stack\Api\IAR\libgat.a; -C ..\..\Stack\Api\IAR\libmap.a
  group (top)
    ./: LinkerConfigurationBootloader.xcl
  group Application
    ../Application/: Accelerometer.c Adc.c BitmapData.c BufferPool.c Buttons.c ClockWidget.c DebugUart.c Fonts.c Icons.c IdleTask.c LcdBuffer.c LcdDisplay.c LcdDriver.c main.c MessageQueues.c MuxMode.c OneSecondTimers.c Property.c SerialRam.c Statistics.c TermMode.c Utilities.c Vibration.c
  group Bootloader
    ../Bootloader/: AltVect.s43 cstartup.s43
  group FreeRTOS
    ../../FreeRTOS/: croutine.c list.c queue.c tasks.c
  group FreeRTOS/include
    ../../FreeRTOS/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h TaskTCB.h
  group FreeRTOS/portable/MemMang
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group FreeRTOS/portable/MSP430F5438A
    ../../FreeRTOS/portable/MSP430F5438/: FreeRTOSConfig.h Lowinit.c port.c portext_s43.asm portmacro.h
  group Hardware
    ../Hardware/: hal_accelerometer.c hal_analog_display.c hal_battery.c hal_boot.c hal_calibration.c hal_clock_control.c hal_lpm.c hal_miscellaneous.c hal_oled.c hal_rtc.c hal_rtos_timer.c hal_software_fll.c hal_vibe.c OledDriver.c
  group Hardware/F5xx_F6xx_Core_Lib
    ../Hardware/F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group OSAL
    ../../OSAL/: MSP430FlashUtil.c
  group Patch
    ../../Patch/: PatchSelection.c
